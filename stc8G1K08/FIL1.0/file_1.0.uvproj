# Keil uVision project file_1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: file_1.0
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FIL1.0
  group Source Group 1
    ./: STARTUP.A51
  group Users
    ./Users/: main.c
  group key_state
    ./key_state/: key_state.c
  group key_light
    ./key_light/: key_light.c
  group delay
    ./delay/: delay.c
  group Timer2
    ./Timer2/: Timer2.c
